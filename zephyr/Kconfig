## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0
menuconfig RMW
        bool "RMW support"
        help
          This option enables RMW

if RMW

endif
```
